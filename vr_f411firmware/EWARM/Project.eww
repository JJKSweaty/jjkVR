<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\vr_f411firmware.ewp</path>
  </project>
  <batchBuild />
</workspace>
